# Keil uVision project ADC.uvproj, settings and files
target Target 1 (166/167)
  device: XE169FH-200F Infineon
  cpu: IRAM(0xF600-0xFDFF) XRAM(0x8000-0xDFFF) XRAM2(0xE00000-0xE1BFFF) IROM(0xC00000-0xC0EFFF) IROM2(0xC10000-0x0xD8FFFF) CLOCK(100000000) MOD167 MODV2
  output: LCD
  group Source Group 1
    ./: START_V3.A66 MAIN.c SCS.c GPT1.c GPT2.c IO.c CC2.c ADC0.c
